options:
  parameters:
    author: guill
    generate_options: no_gui
    id: DoADistEst
    output_language: python
    run_options: run
    title: DoA&DistEst
  states: {}

blocks:
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {state: disabled}
- name: RF_Gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: c
  id: variable
  parameters:
    value: int(3e8)
  states: {}
- name: f_mod
  id: variable_qtgui_range
  parameters:
    label: f_mod
    orient: Qt.Horizontal
    start: 70e6
    step: 1e6
    stop: 6e9
    value: '2000000000'
  states: {state: disabled}
- name: f_mod
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: lanbda
  id: variable
  parameters:
    value: c/f_mod
  states: {}
- name: nsamples
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_pot_dB
  id: variable_qtgui_range
  parameters:
    label: Tx Potencia (dB)
    orient: Qt.Horizontal
    start: '-50'
    step: '1'
    stop: '50'
    value: '-3'
  states: {state: disabled}
- name: tx_pot_dB
  id: variable
  parameters:
    value: '38'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: (lanbda/(4*numpy.pi))**2
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: tx_pot_dB
    type: float
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 500e3
    low_cutoff_freq: 300e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 500e3
    low_cutoff_freq: 300e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 500e3
    low_cutoff_freq: 300e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: nsamples
    max_iter: '4000'
    scale: 1/nsamples
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: nsamples
    max_iter: '4000'
    scale: 1/nsamples
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='dBmeters to meters',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              
              input_items[0] = 10**(input_items[0]/20)
              output_items[0][:] = input_items[0]
              
              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      #Librerias para GPIO
      import RPi.GPIO as GPIO          

      from time import sleep
      import time

      import random
      import paho.mqtt.client as mqtt_client
      from statistics import mode
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, nsamples = 20e3, comparation_level = 1, tolerance = 1.3):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='DoA + Dist Est',   # will show up in GRC
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[np.float32]
              )
              
              # ----- Block self variables ------------------
              self.counter = 0
              self.nsamples = nsamples
              self.min = comparation_level - comparation_level*tolerance
              self.max = comparation_level + comparation_level*tolerance
              self.dist_est_flag = False
              self.dist_estimation = []
              self.do_stuff = True
              self.safe_to_go = True
              self.ignored_samps = 0
              self.decision = []
              self.straight_counter = 0
              # ----------------------------------------
              
              
              # ----- Motores GPIO ---------------------
              #Motor 1
              self.in1 = 22
              self.in2 = 23
              self.en_a = 27
              #Motor 2
              self.in3 = 24
              self.in4 = 25
              self.en_b = 26
              
              GPIO.setwarnings(False)
              #Modo de trabajo GPIO
              GPIO.setmode(GPIO.BCM)
              #Defino los pines como salida
              #Motor 1
              GPIO.setup(self.in1,GPIO.OUT)
              GPIO.setup(self.in2,GPIO.OUT)
              GPIO.setup(self.en_a,GPIO.OUT)
              #Motor 2
              GPIO.setup(self.in3,GPIO.OUT)
              GPIO.setup(self.in4,GPIO.OUT)
              GPIO.setup(self.en_b,GPIO.OUT)

              #Inicializo pines a nivel bajo para q este parado
              GPIO.output(self.in1,GPIO.LOW)
              GPIO.output(self.in2,GPIO.LOW)
              GPIO.output(self.in3,GPIO.LOW)
              GPIO.output(self.in4,GPIO.LOW)
              
              # Genero PWM en el pin enable A (motor 1)
              self.pwm_motor1=GPIO.PWM(self.en_a,800)
              self.pwm_motor1.start(10)

              # Genero PWM en el pin enable B (motor 2)
              self.pwm_motor2=GPIO.PWM(self.en_b,800)
              self.pwm_motor2.start(10)
              # ----------------------------------------
              
              
              # ----- MQTT -----------------------------
              #Direccion del broker
              self.broker_address = '192.168.0.230'
              #Puerto del broker
              self.broker_port = 1883
              #Topicos de PUBLICACION
              self.topic_pub_DoA = "gnuradio2BS_DoA"
              self.topic_pub_DistEst = "gnuradio2BS_DistEst"
              #Topicos de SUBSCRIPCION
              self.topic_sub = "BS2gnuradio"
              #We define the username and passwd according to the configuration of the MQTT broker
              self.username = "utic"
              self.passwd = "123456"
              # Generamos un ID de cliente
              self.client_id = f'python-mqtt-{random.randint(0, 100)}'
              #Nos conectamos
              self.client = self.connect_mqtt()
              self.client.loop_start()
              #self.subscribe(self.client)
              print('despues de subscribe()')
              # ----------------------------------------
              
          #Funcion de conexion al broker
          def connect_mqtt(self) -> mqtt_client:
              def on_connect(client, userdata, flags, rc):
                  if rc == 0:
                      print("Connected to MQTT Broker!\n")
                  else:
                      print("Failed to connect, return code %d\n", rc)

              client = mqtt_client.Client(self.client_id)
              client.username_pw_set(self.username, self.passwd)
              client.on_connect = on_connect
              client.connect(self.broker_address, self.broker_port)
              return client

          
          #Funcion de publicar al broker
          def publish(self, client, msg, topic):
              result = client.publish(topic,msg)
              status = result[0]
              if status == 0:
                print("Success publishing ...")
                print("Topic: " + topic)
              else:
                print("Failed to send message to topic " + topic)
              print("\n")


          def work(self, input_items, output_items):
                      
              if self.do_stuff and self.safe_to_go:
                  if (not self.dist_est_flag):
                      for i in range(len(input_items[0])):
                          if self.counter >= self.nsamples:
                              self.counter = 0
                              
                              if (input_items[0][i] >= self.min) and (input_items[0][i] <= self.max):
                                  self.decision.append('S')
                              
                              elif input_items[0][i] > self.max:
                                  self.decision.append('R')
                                  
                              else:
                                  self.decision.append('L')
                                  
                              if len(self.decision) == 100:
                                  final_decision = mode(self.decision)
                                  print("Decision de DoA: ", final_decision)
                                  
                                  if final_decision == 'S':
                                      GPIO.output(self.in1,GPIO.LOW)
                                      GPIO.output(self.in2,GPIO.LOW)
                                      GPIO.output(self.in3,GPIO.LOW)
                                      GPIO.output(self.in4,GPIO.LOW)
                                      
                                      self.straight_counter+=1
                                      
                                      self.publish(self.client, 'Looking straight to BS ', self.topic_pub_DoA)
                                      
                                      if self.straight_counter == 5:
                                          self.dist_est_flag = True
                                          
                                          self.publish(self.client, 'DoA finished ... changing to Distance Estimation mode ...', self.topic_pub_DoA)
                                          
                                  elif final_decision == 'L':
                                      GPIO.output(self.in1,GPIO.LOW)
                                      GPIO.output(self.in2,GPIO.HIGH)
                                      GPIO.output(self.in3,GPIO.HIGH)
                                      GPIO.output(self.in4,GPIO.LOW)
                                      
                                      self.straight_counter = 0
                                      
                                      self.publish(self.client, 'Rotating to the left', self.topic_pub_DoA)
                                      
                                  else:
                                      GPIO.output(self.in1,GPIO.HIGH)
                                      GPIO.output(self.in2,GPIO.LOW)
                                      GPIO.output(self.in3,GPIO.LOW)
                                      GPIO.output(self.in4,GPIO.HIGH)
                                      
                                      self.straight_counter = 0
                                      
                                      self.publish(self.client, 'Rotating to the right', self.topic_pub_DoA)
                                      
                                  self.decision = []
                          self.counter+=1

                  else:
                      for i in range(len(input_items[2])):
                          if self.counter >= self.nsamples:
                              self.counter = 0
                              self.dist_estimation.append(input_items[2][i])
                              
                              if len(self.dist_estimation) == 100:
                                  dist_estim_mean = np.mean(self.dist_estimation)
                                  print(dist_estim_mean)
                                  self.publish(self.client, str(dist_estim_mean), self.topic_pub_DistEst)
                                  self.do_stuff = False
                                  self.dist_est_flag = False
                                  os.system('pkill -f DoADistEst.py')
                              
                          self.counter+=1
                      
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    comparation_level: '1.3'
    nsamples: nsamples
    tolerance: '0.9'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: note_0
  id: note
  parameters:
    note: Right
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: DoA ->
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Dist Est ->
  states: {}
- name: note_1
  id: note
  parameters:
    note: Left
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DoA_pot_div"'
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: f_mod
    dev_addr: '"serial=31BBEFE"'
    gain0: RF_Gain
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: f_mod
    dev_addr: '"serial=31BA185"'
    gain0: RF_Gain
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_signal_dB
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RX_signal_dB
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_nlog10_ff_0_0_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_0, '0']
- [band_pass_filter_0_1, '0', blocks_complex_to_mag_squared_0_0, '0']
- [band_pass_filter_0_1_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_1_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [blocks_add_xx_0_0, '0', epy_block_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_1, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', virtual_sink_0, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_null_source_0, '0', epy_block_1, '1']
- [blocks_sub_xx_0, '0', blocks_add_xx_0_0, '1']
- [epy_block_0_0, '0', epy_block_1, '2']
- [epy_block_1, '0', blocks_null_sink_0_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0_1, '0']
- [uhd_usrp_source_0_0, '0', band_pass_filter_0_1_0, '0']
- [uhd_usrp_source_0_0, '0', band_pass_filter_0_1_1, '0']
- [virtual_source_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
